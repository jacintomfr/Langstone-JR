options:
  parameters:
    generate_options: no_gui
    id: Lang_TRX_Hack
    output_language: python
  states: {}

blocks:
- name: AFGain
  id: variable
  parameters:
    value: '100'
  states: {}
- name: AMMIC
  id: variable
  parameters:
    value: '5'
  states: {}
- name: CTCSS
  id: variable
  parameters:
    value: '885'
  states: {}
- name: FFT_SEL
  id: variable
  parameters:
    value: '1'
  states: {}
- name: FMMIC
  id: variable
  parameters:
    value: '50'
  states: {}
- name: KEY
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: MicGain
  id: variable
  parameters:
    value: '5.0'
  states: {}
- name: PTT
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: RATE
  id: variable
  parameters:
    value: '0'
  states: {}
- name: RxOffset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Rx_AMP
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: Rx_Base
  id: variable
  parameters:
    value: '62'
  states: {}
- name: Rx_Filt_High
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: Rx_Filt_Low
  id: variable
  parameters:
    value: '300'
  states: {}
- name: Rx_Gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: Rx_LO
  id: variable
  parameters:
    value: '435100000'
  states: {}
- name: Rx_Mode
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Rx_Mute
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: ToneBurst
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: Tx_AMP
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: Tx_Filt_High
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: Tx_Filt_Low
  id: variable
  parameters:
    value: '300'
  states: {}
- name: Tx_Gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Tx_LO
  id: variable
  parameters:
    value: '435100000'
  states: {}
- name: Tx_Mode
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.00002'
    gain: '1.0'
    max_gain: '20'
    reference: '3e-1'
    type: float
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1'
    max_dev: '5000'
    quad_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: '0.99'
    lo: '-0.99'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: 1.0*ToneBurst
    freq: '1750'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: 0.15 * (CTCSS >0)
    freq: CTCSS/10.0
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: '"hw:CARD=Device,DEV=0"'
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '"hw:CARD=Device,DEV=0"'
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: Rx_Filt_High
    low_cutoff_freq: Rx_Filt_Low
    samp_rate: '48000'
    type: fir_filter_ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: Tx_Filt_High
    low_cutoff_freq: Tx_Filt_Low
    samp_rate: '48000'
    type: fir_filter_ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3500'
    low_cutoff_freq: '300'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_mic1
  id: band_pass_filter
  parameters:
    gain: '0.5'
    high_cutoff_freq: '750'
    interp: '1'
    low_cutoff_freq: '100'
    samp_rate: '48000'
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_mic2
  id: band_pass_filter
  parameters:
    gain: '2'
    high_cutoff_freq: '1450'
    interp: '1'
    low_cutoff_freq: '650'
    samp_rate: '48000'
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_mic3
  id: band_pass_filter
  parameters:
    gain: '4'
    high_cutoff_freq: '2350'
    interp: '1'
    low_cutoff_freq: '1450'
    samp_rate: '48000'
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_mic4
  id: band_pass_filter
  parameters:
    gain: '5.2'
    high_cutoff_freq: '3300'
    interp: '1'
    low_cutoff_freq: '2350'
    samp_rate: '48000'
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: (0.5 * int(Tx_Mode==5)) + int(Tx_Mode==2) +int(Tx_Mode==3)
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: 2 ** FFT_SEL
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: 2 ** FFT_SEL
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '(MicGain)*(int(Tx_Mode==0)) + (MicGain)*(int(Tx_Mode==1)) + (AMMIC/10.0)*(int(Tx_Mode==5)) '
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: FMMIC/5.0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: (AFGain/100.0) *  (not Rx_Mute)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: Rx_Mode<4
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (Rx_Mode==4) * 0.2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (Tx_Mode==4) or (Tx_Mode==5)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Rx_Mode==5
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0 + (Rx_Mode==5)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_2
  id: blocks_multiply_const_vxx
  parameters:
    const: Tx_Mode<4
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: Tx_Mode==4
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    const: (Tx_Mode < 4) or (Tx_Mode==5)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_mute_xx_0_0_0
  id: blocks_mute_xx
  parameters:
    mute: (not PTT) or (Tx_Mode==2 and not KEY) or (Tx_Mode==3 and not KEY)
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: PTT
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '512'
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '512'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: RxOffset
    decim: '11'
    samp_rate: '528000'
    taps: firdes.low_pass(1,529200,23000,2000)
    type: ccc
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'True'
    avg_alpha: '0.9'
    fft_size: '512'
    frame_rate: '15'
    ref_scale: '2'
    sample_rate: 48000/ (2 ** FFT_SEL)
    shift: 'False'
    type: complex
  states: {}
- name: logpwrfft_x_0_0
  id: logpwrfft_x
  parameters:
    average: 'True'
    avg_alpha: '0.9'
    fft_size: '512'
    frame_rate: '15'
    ref_scale: '2'
    sample_rate: 48000/ (2** FFT_SEL)
    shift: 'False'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 48/(8000 + 100*RATE)
    type: complex
  states: {}
- name: mmse_resampler_xx_1
  id: mmse_resampler_xx
  parameters:
    alias: 48/49
    maxoutbuf: '8192'
    minoutbuf: '4096'
    phase_shift: '0'
    resamp_ratio: 480/481
    type: float
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '2048'
    port: '7373'
    send_eof: 'False'
    type: float
  states: {}
- name: network_udp_sink_1
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '2048'
    port: '7474'
    send_eof: 'False'
    type: float
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '33'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: Tx_AMP
    center_freq: Tx_LO
    samp_rate: '8000000'
    type: fc32
    vga: Tx_Gain
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: Rx_AMP
    center_freq: Rx_LO
    gain: Rx_Gain
    samp_rate: '8000000'
    type: fc32
    vga: Rx_Base
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_multiply_const_vxx_2_1_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_3, '0']
- [analog_rail_ff_0, '0', band_pass_filter_1, '0']
- [analog_rail_ff_0_0, '0', blocks_float_to_complex_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1_0, '0', blocks_add_xx_0_0, '0']
- [audio_source_0, '0', band_pass_filter_mic1, '0']
- [audio_source_0, '0', band_pass_filter_mic2, '0']
- [audio_source_0, '0', band_pass_filter_mic3, '0']
- [audio_source_0, '0', band_pass_filter_mic4, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_2_0_0, '0']
- [band_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_const_vxx_4, '0']
- [band_pass_filter_1, '0', blocks_add_xx_0_0, '1']
- [band_pass_filter_mic1, '0', blocks_add_xx_0_0_0, '3']
- [band_pass_filter_mic2, '0', blocks_add_xx_0_0_0, '2']
- [band_pass_filter_mic3, '0', blocks_add_xx_0_0_0, '1']
- [band_pass_filter_mic4, '0', blocks_add_xx_0_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', analog_rail_ff_0_0, '0']
- [blocks_add_xx_0, '0', analog_rail_ff_0, '0']
- [blocks_add_xx_0_0, '0', analog_nbfm_tx_0, '0']
- [blocks_add_xx_0_0_0, '0', blocks_multiply_const_vxx_2_2, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_xx_1_0, '0', analog_agc2_xx_0, '0']
- [blocks_add_xx_1_0_0, '0', mmse_resampler_xx_1, '0']
- [blocks_add_xx_2, '0', blocks_mute_xx_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_2_1, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', logpwrfft_x_0, '0']
- [blocks_keep_one_in_n_0_0, '0', logpwrfft_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_1_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_2_0_0, '0', blocks_add_xx_1_0_0, '0']
- [blocks_multiply_const_vxx_2_1, '0', blocks_add_xx_1_0, '1']
- [blocks_multiply_const_vxx_2_1_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_2_2, '0', blocks_add_xx_1_0_0, '1']
- [blocks_multiply_const_vxx_3, '0', blocks_add_xx_2, '0']
- [blocks_multiply_const_vxx_4, '0', blocks_add_xx_2, '1']
- [blocks_multiply_xx_0, '0', band_pass_filter_0_0, '0']
- [blocks_mute_xx_0_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_mute_xx_0_0_0, '0', mmse_resampler_xx_0, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', soapy_hackrf_sink_0, '0']
- [blocks_vector_to_stream_0, '0', network_udp_sink_0, '0']
- [blocks_vector_to_stream_0_0, '0', network_udp_sink_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', band_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_keep_one_in_n_0, '0']
- [logpwrfft_x_0, '0', blocks_vector_to_stream_0, '0']
- [logpwrfft_x_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [mmse_resampler_xx_0, '0', blocks_selector_0, '0']
- [mmse_resampler_xx_1, '0', blocks_multiply_const_vxx_0, '0']
- [mmse_resampler_xx_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_hackrf_source_0, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
